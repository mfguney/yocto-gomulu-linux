# SPDX-License-Identifier: MIT
# Katmanın files/ dizinini arama yolunun başına ekle (Bölüm 7)
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# /etc/hostname içeriği (varsayılan değer MACHINE adıdır)
hostname = "agecidi"
